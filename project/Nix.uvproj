# Keil uVision project Nix.uvproj, settings and files
target Nix (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Nix +hex
  c flags: Optim=1
  c include: ..\nix;..\srccode;..\lib\STM32F10x_StdPeriph_Driver\inc;..\lib\STM32F10x_StdPeriph_Driver\src;..\lib\CMSIS\CM3\CoreSupport
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  scatter file: ..\others\STM3210E-EVAL.sct
  group lib
    ../lib/CMSIS/CM3/CoreSupport/: core_cm3.c core_cm3.h
    ../lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../lib/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group others
    ../others/: startup_stm32f10x_hd.s
  group srccode
    ../srccode/: device.c device.h global.h nix_userdef.h nix_userroot.c nix_userroot.h stm32f10x.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h system_stm32f10x.c system_stm32f10x.h test.c test.h unoptimize.c
  group nix
    ../nix/: nix.h nix_chip.c nix_chip.h nix_chip_inner.h nix_core_a.asm nix_core_a_inner.h nix_core_c.c nix_core_c.h nix_core_c_inner.h nix_inner.h nix_list.c nix_list.h nix_list_inner.h nix_mdsdef.h nix_task.c nix_task.h nix_task_inner.h nix_userroot_inner.h nix_queue.c nix_queue.h nix_queue_inner.h
